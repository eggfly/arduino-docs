# IAR project fire_uart_send_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\projects\fire_uart_send_demo; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: E:\work\飞思卡尔\K60 开发\k60\底层 2.0\fire_Kinetis_代码V2.2\build\config files\fire_RAM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  group app
    ../../src/projects/fire_uart_send_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/projects/fire_uart_send_demo/: include.h isr.h
    ../../src/platforms/: k60_fire.h
